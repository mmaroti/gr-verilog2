options:
  parameters:
    author: mmaroti
    generate_options: qt_gui
    id: test_axis_copy
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '1000'
    min: '0'
    num_samps: '1024'
    repeat: 'True'
    type: int
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: int
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: int
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: verilog2_axis_copy_reg_0
  id: verilog2_axis_copy_reg
  parameters:
    DATA_WIDTH: '8'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_sub_xx_0, '0']
- [analog_random_source_x_0, '0', verilog2_axis_copy_reg_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_int_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_sub_xx_0, '0', blocks_int_to_float_0_0, '0']
- [verilog2_axis_copy_reg_0, '0', blocks_int_to_float_0, '0']
- [verilog2_axis_copy_reg_0, '0', blocks_probe_rate_0, '0']
- [verilog2_axis_copy_reg_0, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
  grc_version: v3.10.1.1-19-g9edfade8
